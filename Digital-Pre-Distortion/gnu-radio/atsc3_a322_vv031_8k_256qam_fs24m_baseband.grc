options:
  parameters:
    author: drmpeg
    generate_options: no_gui
    id: atsc3_a322_vv031_8k_256qam_fs24m_baseband
    output_language: python
    run_options: run
    title: ATSC 3.0 A/322 8K 256QAM 6 MHz 24 Msps Baseband Dataset
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 384000 * (16 + 2)
  states: {}
- name: atsc3_alpbbheader_bb_0
  id: atsc3_alpbbheader_bb
  parameters:
    framesize: FECFRAME_NORMAL
    llscount: LLS_ONE_SERVICE
    llsmode: LLS_OFF
    rate: C9_15
  states: {}
- name: atsc3_bbscrambler_bb_0
  id: atsc3_bbscrambler_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_bch_bb_0
  id: atsc3_bch_bb
  parameters:
    fecmode: PLP_FEC_BCH
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_bootstrap_cc_0
  id: atsc3_bootstrap_cc
  parameters:
    fftsize: FFTSIZE_8K
    flen: '100'
    flmode: FLM_SYMBOL_ALIGNED
    frameinterval: MTTN_100
    guardinterval: GI_5_1024
    l1bmode: L1_FEC_MODE_1
    majorversion: BOOTSTRAP_MAJOR_VERSION_0
    minorversion: BOOTSTRAP_MINOR_VERSION_0
    numpayloadsyms: '72'
    numpreamblesyms: '2'
    outputmode: BOOTSTRAP_INTERPOLATION
    pilotpattern: PILOT_SP3_4
    showlevels: SHOWLEVELS_OFF
    vclip: '3.3'
  states: {}
- name: atsc3_framemapper_cc_0
  id: atsc3_framemapper_cc
  parameters:
    constellation1: MOD_256QAM
    constellation2: MOD_QPSK
    cred: CRED_0
    fecmode: PLP_FEC_BCH
    fftsize: FFTSIZE_8K
    fimode: FREQ_PREAMBLE_ONLY
    firstsbs: SBS_OFF
    flen: '100'
    flmode: FLM_SYMBOL_ALIGNED
    framesize: FECFRAME_NORMAL
    guardinterval: GI_5_1024
    l1bmode: L1_FEC_MODE_1
    l1dmode: L1_FEC_MODE_1
    llsmode: LLS_OFF
    misomode: MISO_OFF
    numpayloadsyms: '72'
    numpreamblesyms: '2'
    paprmode: PAPR_OFF
    pilotboost1: SPB_0
    pilotboost10: SPB_0
    pilotboost11: SPB_0
    pilotboost12: SPB_0
    pilotboost13: SPB_0
    pilotboost14: SPB_0
    pilotboost15: SPB_0
    pilotboost16: SPB_0
    pilotboost2: SPB_4
    pilotboost3: SPB_0
    pilotboost4: SPB_0
    pilotboost5: SPB_0
    pilotboost6: SPB_0
    pilotboost7: SPB_0
    pilotboost8: SPB_0
    pilotboost9: SPB_0
    pilotpattern: PILOT_SP3_4
    plpsize: '0'
    rate: C9_15
    tiblocks: '2'
    tidepth1: TI_DEPTH_1024
    tidepth2: TI_DEPTH_1024
    tidepth3: TI_DEPTH_1024
    tidepth4: TI_DEPTH_1024
    tifecblocks: '14'
    tifecblocksmax: '14'
    tifmode: TIF_NOT_INCLUDED
    timode: TI_MODE_OFF
  states: {}
- name: atsc3_freqinterleaver_cc_0
  id: atsc3_freqinterleaver_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_8K
    firstsbs: SBS_OFF
    guardinterval: GI_5_1024
    mode: FREQ_PREAMBLE_ONLY
    numpayloadsyms: '72'
    numpreamblesyms: '2'
    paprmode: PAPR_OFF
    pilotpattern: PILOT_SP3_4
  states: {}
- name: atsc3_interleaver_bb_0
  id: atsc3_interleaver_bb
  parameters:
    constellation1: MOD_256QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_ldpc_bb_0
  id: atsc3_ldpc_bb
  parameters:
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_modulator_bc_0
  id: atsc3_modulator_bc
  parameters:
    constellation1: MOD_256QAM
    constellation2: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate: C9_15
  states: {}
- name: atsc3_pilotgenerator_cc_0
  id: atsc3_pilotgenerator_cc
  parameters:
    cred: CRED_0
    fftsize: FFTSIZE_8K
    firstsbs: SBS_OFF
    guardinterval: GI_5_1024
    misomode: MISO_OFF
    misotxid: MISO_TX_1_OF_2
    numpayloadsyms: '72'
    numpreamblesyms: '2'
    outputmode: PILOTGENERATOR_TIME
    paprmode: PAPR_OFF
    pilotboost1: SPB_0
    pilotboost10: SPB_0
    pilotboost11: SPB_0
    pilotboost12: SPB_0
    pilotboost13: SPB_0
    pilotboost14: SPB_0
    pilotboost15: SPB_0
    pilotboost16: SPB_0
    pilotboost2: SPB_4
    pilotboost3: SPB_0
    pilotboost4: SPB_0
    pilotboost5: SPB_0
    pilotboost6: SPB_0
    pilotboost7: SPB_0
    pilotboost8: SPB_0
    pilotboost9: SPB_0
    pilotpattern: PILOT_SP3_4
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/Ausilon/Desktop/dpd_v1/dpd_soc_min/datasets/atsc3_a322_vv031_8k_256qam_fs24m/atsc3_a322_vv031_8k_256qam_baseband_fs24m_complex64.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/Ausilon/miniconda3/datasets/sample_1280x720.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: Limit output to 262144 complex samples at 24 Msps
    num_items: '262144'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '1024'
    input_size: '8192'
    tagname: ''
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample native 6.912 Msps ATSC 3.0 baseband to 24 Msps
    decim: '36'
    fbw: '0.40'
    interp: '125'
    taps: ''
    type: ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: frame_freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: frame_freq
  states: {}

connections:
- [atsc3_alpbbheader_bb_0, '0', atsc3_bbscrambler_bb_0, '0']
- [atsc3_bbscrambler_bb_0, '0', atsc3_bch_bb_0, '0']
- [atsc3_bch_bb_0, '0', atsc3_ldpc_bb_0, '0']
- [atsc3_bootstrap_cc_0, '0', rational_resampler_xxx_0, '0']
- [atsc3_framemapper_cc_0, '0', virtual_sink_0, '0']
- [atsc3_freqinterleaver_cc_0, '0', atsc3_pilotgenerator_cc_0, '0']
- [atsc3_interleaver_bb_0, '0', atsc3_modulator_bc_0, '0']
- [atsc3_ldpc_bb_0, '0', atsc3_interleaver_bb_0, '0']
- [atsc3_modulator_bc_0, '0', atsc3_framemapper_cc_0, '0']
- [atsc3_pilotgenerator_cc_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [blocks_file_source_0, '0', atsc3_alpbbheader_bb_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', atsc3_bootstrap_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_head_0, '0']
- [virtual_source_0, '0', atsc3_freqinterleaver_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
